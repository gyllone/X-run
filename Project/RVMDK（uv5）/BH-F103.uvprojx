# Keil uVision project BH-F103.uvprojx, settings and files
target stepcounter (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stepcounter +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\adc;..\..\User\AT24C16;..\..\User\rtc;..\..\User\usart;..\..\User\iwdg;..\..\User\chipid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h crypto.c functional.c eeprom.c
    ../../User/Led/: bsp_led.c
    ../../User/adc/: bsp_adc.c
    ../../User/AT24C16/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../../User/usart/: bsp_usart.c
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/chipid/: bsp_chipid.c
  group DOC
    ../../Doc/: readme.txt
